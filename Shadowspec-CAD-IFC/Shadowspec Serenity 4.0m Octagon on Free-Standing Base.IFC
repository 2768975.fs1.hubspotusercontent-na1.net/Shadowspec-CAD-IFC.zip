Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Shadowspec 4.0M Serenity Octagon on Free Standing Base.IFC
Time: 2025-03-05T01:59:54
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Imported1 (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported2 (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported3 (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported5
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Shadowspec - UM - 110069
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110070
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110075
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110075-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110079
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110080 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110081
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110083(Default) (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110085 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110087(Default) (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110089 (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110091(Default) (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110092 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110093 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110094
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110096_PD
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110098
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110102
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110134
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210005 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210019 (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210037 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Rib Pivot (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Rib Tip (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Rotation Disk
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Spar Pivot
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec_4M Octagonal Fabric Canopy
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec_Serenity Mast
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec_Serenity Mast End-Cap
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110232(Default)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_61.5 TOP CAP-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_61.5 TOP CAP-2-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_61.5 TOP CAP-2-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_61.5 TOP CAP-2-3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-2-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-2-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-2-3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-H-TB-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-H-TB-2-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-H-TB-2-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-H-TB-2-3
In: Default Storey
PredefinedType: ELEMENT; Material: 0
