Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Shadowspec 2.5M Square Unity DUO on Free Standing Base.IFC
Time: 2025-03-05T19:38:02
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
