Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Shadowspec 3.0M Square Unity UNO on Free Standing Base.IFC
Time: 2025-03-05T23:54:57
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Imported1 (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported2 (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported3 (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported5
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Scale1[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Scale1[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Shadowspec - UM - 110069 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110070 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110075
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110075-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110079
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110085 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110092 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110093 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110094
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110096_PD
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110098
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110102
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110112
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110117
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110124
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110125_Default<As Machined>
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110126
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110134
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210026
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210037 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Rib Pivot (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Rib Tip (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Spar Pivot
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110186
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110187(Default)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110187b(Default)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110189(Default) (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110190 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110191(Default) (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110232(Default)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Um - 110192 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_61.5 TOP CAP-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_61.5 TOP CAP-2-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_61.5 TOP CAP-2-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_61.5 TOP CAP-2-3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-2-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-2-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-2-3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-H-TB-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-H-TB-2-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-H-TB-2-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-H-TB-2-3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: socket countersunk head screw_am(B18.3.5M - 5 x 0.8 x 10 Socket FCHS -- 10N) (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
