Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Shadowspec 3.0M Square Unity QUAD on Ground Anchor.IFC
Time: 2025-03-05T19:27:13
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Imported1 (12)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported2 (12)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported3 (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Shadowspec - UM - 110069 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110070 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110075 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110075-1 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110079 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110085 (12)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110092 (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110093 (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110094 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110096_PD (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110098 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110102 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110112
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110117
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110124
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110125_Default<As Machined>
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110126
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110134 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210026
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210037 (16)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec In-Ground Anchor
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Rib Pivot (28)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Rib Tip (28)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Spar Pivot (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110089 (32)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110186 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110187(Default) (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110187b(Default) (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110189(Default) (12)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110190 (12)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110191(Default) (16)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Um - 110192 (16)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: parallel pin hardened_bsi(BS EN ISO 8734 - 6 x 32 - A - St) (16)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: socket countersunk head screw_am(B18.3.5M - 5 x 0.8 x 10 Socket FCHS -- 10N) (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
