Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Shadowspec 2.5M Square Unity TRIO on Ground Anchor.IFC
Time: 2025-03-05T20:06:14
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 2.5M_UM - 110081-1 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 2.5M_UM - 110083(Default) (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 2.5M_UM - 110083b(Default) (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 2.5M_UM - 110095 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 2.5M_UM - 110182(Default) (9)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 2.5M_UM - 110183 (9)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 2.5M_UM - 110184(Default) (12)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 2.5M_UM - 110185 (12)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Imported1 (6)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported2 (6)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported3 (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Shadowspec - UM - 110069 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110070 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110075-1-1 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110075-2 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110079-1 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110084-1 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110085-1 (9)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110088-1 (21)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110092-1 (6)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110093-1 (6)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110094-1 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110096_PD-1 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110098-1 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110102-1 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110112
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110117
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110124
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110125_Default<As Machined>
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110126
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110131-1 (21)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110134-1 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210026
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210037-1 (12)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec In-Ground Anchor
In: Default Storey
PredefinedType: ELEMENT; Material: 0
