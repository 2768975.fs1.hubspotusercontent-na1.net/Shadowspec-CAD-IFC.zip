Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Shadowspec 4.0M Octagon Unity DUO on Free Standing Base.IFC
Time: 2025-03-05T03:51:03
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Imported1 (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported2 (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported3 (3)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported5
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Shadowspec - UM - 110069 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110070 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110075 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110075-1 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110079 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110080 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110081 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110083(Default) (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110085 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110087(Default) (14)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110089 (14)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110091(Default) (14)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110092 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110093 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110094 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110096_PD (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110098 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110102 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110112
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110117
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110124
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110125_Default<As Machined>
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110126
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110134 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210005 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210019 (14)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210026
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210037 (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Rib Pivot (14)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Rib Tip (14)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Spar Pivot (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec_4M Octagonal Fabric Canopy (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: UM - 110232(Default)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_61.5 TOP CAP-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_61.5 TOP CAP-2-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_61.5 TOP CAP-2-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_61.5 TOP CAP-2-3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-2-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-2-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-2-3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-H-TB-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-H-TB-2-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-H-TB-2-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Wheelco_WCU75-H-TB-2-3
In: Default Storey
PredefinedType: ELEMENT; Material: 0
