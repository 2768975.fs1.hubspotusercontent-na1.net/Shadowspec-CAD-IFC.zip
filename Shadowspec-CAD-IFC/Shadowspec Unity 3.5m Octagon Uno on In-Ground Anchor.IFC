Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Shadowspec 3.5M Octagon Unity UNO on Ground Anchor.IFC
Time: 2025-03-05T21:02:26
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 3.5M_UM - 110095
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 3.5M_UM - 110193
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 3.5M_UM - 110194
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 3.5M_UM - 110194b
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 3.5M_UM - 110196 (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 3.5M_UM - 110197 (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Fillet2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Imported3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Shadowspec - UM - 110069 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110070 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110075
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110075-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110079
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110085 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110092 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110093 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110094
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110096_PD
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110098
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110102
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110112
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110117
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110124
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110125_Default<As Machined>
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110126
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 110134
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210026
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec - UM - 210037 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec In-Ground Anchor
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Rib Pivot (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Rib Tip (7)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Shadowspec Spar Pivot
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Split Line1
In: Default Storey
PredefinedType: ELEMENT
